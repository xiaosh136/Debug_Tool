
 WCLEAR

 SYStem.Up
 
 enddo
